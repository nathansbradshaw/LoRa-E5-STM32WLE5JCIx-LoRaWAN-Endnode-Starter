# IAR project STM32WLE5JCIx.ewp, settings and files
configuration STM32WLE5JCIx (ARM, debug)
  General.OGChipSelectEditMenu: STM32WLE5JC ST STM32WLE5JC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 5
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32WLE5xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32WLxx_HAL_Driver/Inc; ../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../Drivers/CMSIS/Include; ../LoRaWAN/App; ../LoRaWAN/Target; ../Utilities/trace/adv_trace; ../Utilities/misc; ../Utilities/sequencer; ../Utilities/timer; ../Utilities/lpm/tiny_lpm; ../Middlewares/Third_Party/LoRaWAN/LmHandler/Packages; ../Middlewares/Third_Party/SubGHz_Phy; ../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver; ../Middlewares/Third_Party/LoRaWAN/Crypto; ../Middlewares/Third_Party/LoRaWAN/Mac/Region; ../Middlewares/Third_Party/LoRaWAN/Mac; ../Middlewares/Third_Party/LoRaWAN/LmHandler; ../Middlewares/Third_Party/LoRaWAN/Utilities
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32WLE5JCIx.hex
  ILINK.IlinkOutputFile: STM32WLE5JCIx.out
  ILINK.IlinkIcfFile: stm32wle5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wle5xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32_lpm_if.c sys_app.c sys_debug.c sys_sensors.c timer_if.c adc_if.c usart_if.c stm32wlxx_it.c stm32wlxx_hal_msp.c
  group Application/User/LoRaWAN/Target
    ../LoRaWAN/Target/: radio_board_if.c
  group Application/User/LoRaWAN/App
    ../LoRaWAN/App/: app_lorawan.c CayenneLpp.c lora_app.c lora_info.c
  group Drivers/STM32WLxx_HAL_Driver
    ../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_ll_adc.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_i2c.c stm32wlxx_hal_i2c_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wlxx.c
  group Middlewares/LoRaWAN
    ../Middlewares/Third_Party/LoRaWAN/LmHandler/Packages/: LmhpCompliance.c
    ../Middlewares/Third_Party/LoRaWAN/Crypto/: cmac.c lorawan_aes.c soft-se.c
    ../Middlewares/Third_Party/LoRaWAN/Mac/Region/: Region.c RegionAS923.c RegionAU915.c RegionBaseUS.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionRU864.c RegionUS915.c
    ../Middlewares/Third_Party/LoRaWAN/Mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacParser.c LoRaMacSerializer.c
    ../Middlewares/Third_Party/LoRaWAN/LmHandler/: LmHandler.c NvmDataMgmt.c
    ../Middlewares/Third_Party/LoRaWAN/Utilities/: utilities.c
  group Middlewares/SubGHz_Phy
    ../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver/: radio_driver.c radio_fw.c radio.c
  group Utilities
    ../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../Utilities/sequencer/: stm32_seq.c
    ../Utilities/timer/: stm32_timer.c
    ../Utilities/lpm/tiny_lpm/: stm32_lpm.c
